# Keil uVision project STM32H723.uvprojx, settings and files
target STM32H723 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H723 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MAT_CM7,ARM_MATH_DSP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Drivers\User\Inc;..\FatFs;..\Drivers\CMSIS\DSP\Include;..\Drivers\CMSIS\NN\Include;..\Core\NNExamples;..\Core\GPR-SPC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/Core/NNExamples
    ../Core/NNExamples/: arm_nnexamples_cifar10_inputs.h arm_nnexamples_cifar10_parameter.h arm_nnexamples_cifar10_weights.h
  group Application/User/Core/GPR-SPC
    ../Core/GPR-SPC/: GPR-SPC.c GPR-SPC.h
  group Drivers/User
    ../Drivers/User/Src/: led.c usart.c sdmmc_sd.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/CMSIS/DSP
    ../Drivers/CMSIS/Lib/: arm_cortexM7lfdp_math.lib
  group Drivers/CMSIS/NN
    ../Drivers/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q7.c arm_nn_activations_q15.c arm_relu_q7.c arm_relu_q15.c
    ../Drivers/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c
    ../Drivers/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c
    ../Drivers/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q7.c arm_nn_mult_q15.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
    ../Drivers/CMSIS/NN/Source/PoolingFunctions/: arm_pool_q7_HWC.c
    ../Drivers/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q7.c arm_softmax_q15.c
  group Fatfs
    ../FatFs/: diskio.c ff.c ff_gen_drv.c ffunicode.c sd_diskio.c
software components: CMSIS:CORE 5.5.0
